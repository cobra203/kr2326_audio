# IAR project kr2326_audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051K8 ST STM32F051K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F051
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\STM32F0xx\Include; Driver\I2C_CPAL_Driver\inc; Driver\StdPeriph_Driver\inc; User\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: kr2326_audio.hex
  ILINK.IlinkOutputFile: kr2326_audio.out
  ILINK.IlinkIcfFile: Linker\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application/EWARM
    CMSIS/STM32F0xx/Source/: startup_stm32f0xx.s
  group Application/Linker
    Linker/: stm32f0xx_flash.icf
  group Application/User
    User/src/: cobra_button.c cobra_cmd.c cobra_console.c cobra_event.c cobra_led.c cobra_list.c cobra_sys.c cobra_timer.c main.c mod_audio.c mod_pair.c mod_power.c mod_wireless.c stm32f0xx_it.c system_stm32f0xx.c
  group Drivers/StdPeriph
    Driver/StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
